## boards/shields/bento/Kconfig.shield
```kconfig
# No whitespace after the comma or in your keyboard name!
config SHIELD_BENTO
    def_bool $(shields_list_contains,bento)
```
